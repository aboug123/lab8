# Keil uVision project PeriodicTimer0AInts.uvprojx, settings and files
target PeriodicTimer0AInts (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicTimer0AInts
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PeriodicTimer0AInts.c Dac.h Switch.h Dac.c Switch.c Tracks.c Tracks.h
    ../inc/: PLL.c Timer0A.c
software components: CMSIS:CORE 5.0.2
